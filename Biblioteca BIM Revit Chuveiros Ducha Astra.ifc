Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2025-07-31T08:04:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - IU alternativa 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 31 08:04:12 2025 * Host: DNG1464 * Database: C:\Users\maria.cardoso\AppData\Local\Temp\2cebf37a-41d4-424a-ae11-64d3ba6ea87f\d3305577-7297-4896-b2f1-78efa3356b66\ifc * Database version: 5507 * Database creation date: Thu Jul 31 08:04:05 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 31 08:04:05 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 31 08:04:05 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Vista Principal
LongName: Vista Principal; Elevation: 0 mm

# IfcBuildingElementProxy: Texto do modelo:Subtextos, Texto do modelo:Subtextos:489321
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: Subtextos
Type - Pset_QuantityTakeOff - Reference: Subtextos
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Width: 10 mm; Height: 18.8356 mm; Depth: 10 mm

# IfcBuildingElementProxy: Texto do modelo:Termo, Texto do modelo:Termo:489322
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: Termo
Type - Pset_QuantityTakeOff - Reference: Termo
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Texto do modelo:Texto (2)
In: Vista Principal
Type - Pset_BuildingElementProxyCommon - Reference: Texto
Type - Pset_QuantityTakeOff - Reference: Texto
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Width: 10 mm; Height: 7.53422 mm; Depth: 10 mm
Name (Texto do modelo:Texto:...)
489329
489330

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_772374
Port_770909

# IfcFlowTerminal: Astra - Chuveiro com Braço Curvo - CCV:CCV1, Astra - Chuveiro com Braço Curvo - CCV:CCV1:770909
In: Vista Principal
Type - Material: PP Branco, PVC Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: CCV1
Pset_DistributionFlowElementCommon - Reference: CCV1; sets with these values: 2

# IfcFlowTerminal: Astra - Chuveiro com Braço Reto - CV:CV41, Astra - Chuveiro com Braço Reto - CV:CV41:772374
In: Vista Principal
Type - Material: PP Branco, PVC Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Astra
Type - Pset_QuantityTakeOff - Reference: CV41
Pset_DistributionFlowElementCommon - Reference: CV41; sets with these values: 3
Pset_ManufacturerTypeInformation - sets with these values: 2
